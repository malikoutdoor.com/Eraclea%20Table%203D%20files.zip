Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:53:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:53:08 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{72F9A473-5EF4-4287-A9C5-5FEBA0A54A54}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:53:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:53:04 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:53:04 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR102 - GRANITO, Tavolo ERACLEA:0PAAR102 - GRANITO:153787
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Tavolo ERACLEA
Type - Dati identità - BIM Name: ERACLEA T; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR102; Designer: BELLITALIA DESIGN; Family Name: ERACLEA; Nome del tipo: 0PAAR102 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/tables/eraclea-table/; URL Ita: https://www.bellitalia.net/prodotti/tavoli/eraclea-table/
Type - Dimensioni - Dimensions: 2200 mm X 976 mm X 786 mm
Type - Generale - Descrizione Tecnica Famiglia: "Tavolo lineare “ERACLEA” dotato di due elementi laterali di sostegno. Il piano orizzontale del tavolo monolitico è realizzato con sezione ottimale rispetto alle sollecitazioni e all’ergonomia dello stesso."; Descrizione Tecnica per Codice: TAVOLO ERACLEA T IN GRANITO (COLORE A SCELTA) SABBIATO CON PIANO SUPERIORE SPAZZOLATOVERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "“ERACLEA” linear table equipped with two elements support sides. The horizontal plane of the table monolithic is made with an optimal section compared to the stresses and ergonomics of the same."; Technical Description for Article: ERACLEA T TABLE IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED UPPER SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE TAVOLO: GRANITO; Primary Material: Reconstituted White Granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 1385 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR102 - GRANITO
Altro - Famiglia: Tavolo ERACLEA: 0PAAR102 - GRANITO; Famiglia e tipo: Tavolo ERACLEA: 0PAAR102 - GRANITO; ID tipo: Tavolo ERACLEA: 0PAAR102 - GRANITO; Tipo: Tavolo ERACLEA: 0PAAR102 - GRANITO
Dimensioni - Area: 4.01973 m2; Volume: 0.562145 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
